# Keil uVision project Project.uvprojx, settings and files
target GrEq-STM32F746G-DISCO (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2004FFFF) IRAM(0x00000000-0x3FFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM7,USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_IOEXPANDER,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/ST/STM32_Audio/Addons/GREQ/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/Common/Inc
  library: MicroLIB
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_i2c.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2s.c stm32f7xx_ll_usb.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_flash.c stm32f7xx_hal_sai.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_hcd.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sdram.c stm32f7xx_hal.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_gpio.c
  group Application/User
    ../Src/: usbh_conf.c stm32f7xx_it.c waveplayer.c usbh_diskio.c main.c explorer.c menu.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_ctlreq.c usbh_pipes.c
  group Drivers/BSP/STM32746G-Discovery
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_audio.c stm32746g_discovery_sdram.c stm32746g_discovery.c stm32746g_discovery_ts.c stm32746g_discovery_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Middlewares/GREQ
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/GREQ/Lib/: GREQ_CM7_Keil.lib
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
software components: CMSIS:CORE 4.3.0
