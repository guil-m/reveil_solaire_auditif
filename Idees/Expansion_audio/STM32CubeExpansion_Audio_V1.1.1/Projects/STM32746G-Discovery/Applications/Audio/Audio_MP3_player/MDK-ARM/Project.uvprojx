# Keil uVision project Project.uvprojx, settings and files
target MP3-STM32F746G-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2004FFFF) IRAM(0x00000000-0x3FFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM7,USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_IOEXPANDER,USE_USB_FS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC236/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC441/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/Common/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC236/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC441/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/Common/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM;../../../../../../Middlewares/ST/STM32_Audio/AudioFramework/Inc;../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_rcc.c stm32f7xx_hal.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2s.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_sai.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_ll_usb.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_pipes.c usbh_ctlreq.c usbh_core.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group Application/User
    ../Src/: usbh_diskio.c explorer.c stm32f7xx_it.c usbh_conf.c main.c menu.c coders.c fwkmempool.c mp3process.c player.c songutilities.c wavprocess.c
  group Middlewares/SRC
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC236/Lib/: SRC236_CM7_Keil.lib
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC441/Lib/: SRC441_CM7_Keil.lib
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM32746G-Discovery
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sdram.c stm32746g_discovery.c stm32746g_discovery_ts.c stm32746g_discovery_lcd.c stm32746g_discovery_audio.c
  group Middlewares/AudioCodecs/MP3Decoder
    ../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/lib/: lib_mp3decoder_cortex_m7_v2.2.0.a
software components: CMSIS:CORE 4.3.0
