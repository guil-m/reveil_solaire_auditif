# IAR project Project.ewp, settings and files
configuration MP3-STM32F469I-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32F469xx; USE_STM32F469I_DISCO; USE_IOEXPANDER; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F469I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\SRC236\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\SRC441\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\Common\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\AudioFramework\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Codecs\SpiritDSP_MP3_Dec\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Codecs\SpiritDSP_MP3_Enc\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F469I_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f469xx.s
  group Application/User
    ../Src/: coders.c explorer.c fwkmempool.c main.c menu.c mp3process.c player.c recorder.c songutilities.c stm32f4xx_it.c usbh_conf.c usbh_diskio.c wavprocess.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/BSP/STM32F469I-Discovery
    ../../../../../../Drivers/BSP/STM32F469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_audio.c stm32469i_discovery_lcd.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group Middlewares/AudioCodecs/MP3Decoder
    ../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/lib/: lib_mp3decoder_cortex_m4_v2.2.0.a
  group Middlewares/AudioCodecs/MP3Encoder
    ../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Enc/lib/: lib_mp3encoder_cortex_m4_v2.2.0.a
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_IAR.a
  group Middlewares/SRC
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC236/Lib/: SRC236_CM4_IAR.a
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC441/Lib/: SRC441_CM4_IAR.a
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
