# Keil uVision project Project.uvprojx, settings and files
target MP3-STM32F469I-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F469xx,USE_STM32F469I_DISCO,USE_IOEXPANDER,USE_USB_FS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F469I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC236/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC441/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/Common/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM;../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/inc;../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Enc/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_Keil.lib
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
  group Application/User
    ../Src/: menu.c explorer.c stm32f4xx_it.c main.c usbh_conf.c usbh_diskio.c mp3process.c songutilities.c wavprocess.c coders.c fwkmempool.c player.c recorder.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sai.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_uart.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/SRC
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC441/Lib/: SRC441_CM4_Keil.lib
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SRC236/Lib/: SRC236_CM4_Keil.lib
  group Drivers/BSP/STM32F469I-Discovery
    ../../../../../../Drivers/BSP/STM32F469I-Discovery/: stm32469i_discovery_ts.c stm32469i_discovery_audio.c stm32469i_discovery_sdram.c stm32469i_discovery_lcd.c stm32469i_discovery.c
  group Middlewares/AudioCodecs/MP3Decoder
    ../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/lib/: lib_mp3decoder_cortex_m4_v2.2.0.a
  group Middlewares/AudioCodecs/MP3Encoder
    ../../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Enc/lib/: lib_mp3encoder_cortex_m4_v2.2.0.a
software components: CMSIS:CORE 5.0.2
